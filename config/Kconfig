## config/Kconfig
```kconfig
config SEL_WORD_MOD
    string
    default LGUI

config SEL_WORD_DELAY
    int
    default 1
```
